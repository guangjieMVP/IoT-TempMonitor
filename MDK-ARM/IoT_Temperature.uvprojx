# Keil uVision project IoT_Temperature.uvprojx, settings and files
target IoT_Temperature (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IoT_Temperature +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/RT-Thread//include/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: main.c gpio.c app_rtthread.c sys.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c led.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RT-Thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 4.3.0
